# Keil uVision project Temperature_Humidity_Acquisition.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.1.20.4
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: Temperature_Humidity_Acquisition +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: ..\SDK\CMSIS\CoreSupport;..\SDK\SWM341_StdPeriph_Driver;..\SDK\CMSIS\DeviceSupport;..\Driver\LCD\ugui;..\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ../Main/: main.h main.c
  group Driver
    ../Driver/LCD/: lcd.c
    ../Driver/LCD/ugui/: ugui.c
    ../Driver/RS485/: rs485.c rs485_host.c
    ../Driver/UART/: uart.c
  group Driver/CRC
    ../Driver/RS485/CRC/: modbus_crc16.c modbus_crc16.h
  group Core
    ../Core/: startup_SWM341.s system_SWM341.c dev_systick.c
    ../SDK/SWM341_StdPeriph_Driver/: SWM341_flash.c SWM341_port.c
  group SDK
    ../SDK/SWM341_StdPeriph_Driver/: SWM341_gpio.c SWM341_lcd.c SWM341_pwm.c SWM341_sdram.c SWM341_uart.h SWM341_uart.c SWM341_sdio.c
    ../Driver/TF/FatFs/: diskio.c ff.c ffunicode.c
